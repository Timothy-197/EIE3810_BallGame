# Keil uVision project Lab6.uvprojx, settings and files
target Lab0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: _Lab6 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\Board;.\Core;.\Fw_lib\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Fw_lib
    ./Fw_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Core
    ./Core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Board
    ./Board/: EIE3810_Buzzer.c EIE3810_Key.c EIE3810_LED.c EIE3810_Clock.c EIE3810_USART.c EIE3810_TFTLCD.c EIE3810_Lab3.c EIE3810_Timer.c EIE3810_ExternalInterrupt.c
  group User
    ./User/: main.c stm32f10x_it.c
